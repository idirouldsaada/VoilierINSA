# Keil uVision project TP_GPIO.uvproj, settings and files
target Simulation (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TP_GPIO
  AfterMake: "C:\Program Files (x86)\CodeSourcery\Sourcery_CodeBench_Lite_for_ARM_EABI\bin\arm-none-eabi-size.exe"
  group src
    ./src/: Test_GPIO.c clock.c test_timer.c
    ../../pilotes/gpio/: pilote_IO.c pilote_IO.h
    ../../pilotes/ADC/: pilote_ADC.c pilote_ADC.h
    ../../pilotes/timer/: pilote_TIMER.c pilote_TIMER.h
    ../../Services/Service_Servo/: Service_Servo.c Service_Servo.h
    ../../Services/Service_Girouette/: Service_Girouette.c Service_Girouette.h
  group Boot
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TP_GPIO
  AfterMake: as above
